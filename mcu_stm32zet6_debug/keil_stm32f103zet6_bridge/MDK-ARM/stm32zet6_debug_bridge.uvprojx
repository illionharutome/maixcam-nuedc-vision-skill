# Keil uVision project stm32zet6_debug_bridge.uvprojx, settings and files
target STM32F103ZET6 Debug Bridge (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: stm32zet6_debug_bridge +hex
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: ..\USER;..\..\..\mcu_common;..\..\..\mcu_tmx3507\app;..\..\examples
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c bridge_config.h
  group Startup
    ../CMSIS/: startup_stm32f10x_hd.s
  group Shared MV Parser
    ../../../mcu_common/: mv_parser.c
  group Aiming State Machine
    ../../../mcu_tmx3507/app/: target_aiming_state_machine.c
  group STM32 Debug Bridge
    ../../examples/: example_receive_aiming.c
